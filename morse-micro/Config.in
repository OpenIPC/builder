## morse-micro/Config.in
```kconfig
config BR2_PACKAGE_MORSE_MICRO
	bool "morse-micro"
	help
        Morse Micro Wi-Fi HaLow driver for OpenIPC
```
